# IAR project SWSYS.ewp, settings and files
configuration SWSYS (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F407xx
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../Drivers/CMSIS/Include; ..\Core\ASW\S2_CH; ..\Core\ASW\S1_INV; ..\Core\ASW\S4_Batt; ..\Core\ASW\S5_VGBR; ..\Core\BSW\DBG; ..\Core\BSW\LIB; ..\Core\Src; ..\Core\ASW\mntData; ..\Core\ASW\S3_HMI; ..\Core\BSW\HAL\RTC; ..\Core\BSW\HAL\Temp; ..\Core\ASW\Ctrl; ..\Core\RTE\RTE_MNT; ..\Core\ASW\SMU; ..\Core\RTE\RTE_MB; ../FATFS/Target; ../FATFS/App; ../Middlewares/Third_Party/FatFs/src
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SWSYS.hex
  ILINK.IlinkOutputFile: SWSYS.out
  ILINK.IlinkIcfFile: stm32f407xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: cmd.c ds1307_for_stm32_hal.c httpFrame.c iflash.c MAC.c modbus.c modbus.h sim7600http.c sysvar.c main.c gpio.c adc.c dma.c i2c.c iwdg.c rtc.c sdio.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Application/User/Core/ASW/Ctrl
    ../Core/ASW/Ctrl/: Ctrl.c Ctrl.h
  group Application/User/Core/ASW/S1_INV
    ../Core/ASW/S1_INV/: S1_INV.c S1_INV.h
  group Application/User/Core/ASW/S2_CH
    ../Core/ASW/S2_CH/: S2_CH.c S2_CH.h
  group Application/User/Core/ASW/S3_HMI
    ../Core/ASW/S3_HMI/: S3_HMI.c S3_HMI.h
  group Application/User/Core/ASW/S4_BAT
    ../Core/ASW/S4_Batt/: S4_Batt.c S4_Batt.h
  group Application/User/Core/ASW/S5_VGBR
    ../Core/ASW/S5_VGBR/: S5_VGBR.c S5_VGBR.h
  group Application/User/Core/ASW/SMU
    ../Core/ASW/mntData/: mntdata.c mntdata.h
    ../Core/ASW/SMU/: smu.c smu.h
  group Application/User/Core/BSW/DBG
    ../Core/BSW/DBG/: dbg.c dbg.h
  group Application/User/Core/BSW/HAL/RTC
    ../Core/BSW/HAL/RTC/: myrtc.c myrtc.h
  group Application/User/Core/BSW/HAL/Temp
    ../Core/BSW/HAL/Temp/: tempSensor.c tempSensor.h
  group Application/User/Core/BSW/LIB
    ../Core/BSW/LIB/: crc.c crc.h
  group Application/User/Core/RTE/RTE_MB
    ../Core/RTE/RTE_MB/: RTE_MB.c RTE_MB.h
  group Application/User/Core/RTE/RTE_MNT
    ../Core/RTE/RTE_MNT/: RTE_MNT_WEB.c RTE_MNT_WEB.h
  group Application/User/FATFS/Target
    ../FATFS/Target/: bsp_driver_sd.c sd_diskio.c fatfs_platform.c
  group Application/User/FATFS/App
    ../FATFS/App/: fatfs.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_adc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_sd.c stm32f4xx_hal_mmc.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c
